require recipes-extended/images/core-image-test.bb

IMAGE_INSTALL += "\
    mmsens-app \
    i2c-tools \
"

